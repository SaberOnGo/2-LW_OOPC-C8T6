# Keil uVision project 1_PM25Sensor_0221.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 1_PM25Sensor_0221 +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,
  c include: ..\Library\inc;..\System\CMSIS;..\System\startup;..\Driver\inc;..\OS\inc;..\User\inc;..\Component\SFUD-master\others;..\Component\SFUD-master\sfud\inc;..\Component\USB\UsbApp;..\Component\USB\LIB\inc;..\Component\USB\Usb_LIB\inc;..\Component\FatFs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Library
    ../Library/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c
    ../Library/inc/: misc.h stm32f10x_gpio.h stm32f10x_fsmc.h stm32f10x_rcc.h
  group User
    ../User/src/: main.c stm32f10x_it.c Application.c SDRR.c
    ../Driver/src/: TimerManager.c F10X_Flash_If.c
  group Driver
    ../Driver/src/: delay.c LCD1602_Drv.c my_debug.c PM25Sensor.c Key_Drv.c LED_Drv.c uart_queue.c Uart_Drv.c rom_flash_interface.c sd_card_interface.c spi_flash_interface.c DHT11.c stm32f1_temp_sensor.c
    ../OS/src/: os_global.c os_timer.c
  group CMSIS
    ../System/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group startup
    ../System/startup/: startup_stm32f10x_md.s
  group SFUD
    ../Component/SFUD-master/others/: bsp.c sfud_demo.c
    ../Component/SFUD-master/sfud/port/: sfud_port.c
    ../Component/SFUD-master/sfud/src/: sfud.c sfud_sfdp.c
  group USB
    ../Component/USB/UsbApp/: UsbApp.c
    ../Component/USB/LIB/src/: disk_image.c hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group USBLib
    ../Component/USB/Usb_LIB/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group FatFs
    ../Component/FatFs/src/: diskio.c fatfs_demo.c ff.c
    ../Component/FatFs/option/: ccsbcs.c
